# i.MX8MP SolidRun Boards support optee-os like imx8mpevk
COMPATIBLE_MACHINE:imx8mpsolidrun = "imx8mpsolidrun"
OPTEEMACHINE:imx8mpsolidrun = "imx-mx8mpevk"
