# i.MX8MP SolidRun Boards support fTPM
COMPATIBLE_MACHINE:imx8mpsolidrun  = "imx8mpsolidrun"
